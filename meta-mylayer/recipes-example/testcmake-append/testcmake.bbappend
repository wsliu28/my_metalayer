FILESEXTRAPATHS:prepend:= "${THISDIR}/${PN}:"


SRC_URI:append = " file://test2.cpp"

